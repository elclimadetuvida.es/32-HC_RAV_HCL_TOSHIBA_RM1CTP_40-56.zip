Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2019-04-23T14:29:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 14:29:59 2019 * Host: DS-SGH416PJCY * Database: C:\Users\AMITSH~1.K\AppData\Local\Temp\{FA6C9CF7-FCDF-4801-9C37-7E28E8F4E308}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 14:29:57 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 14:29:57 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 14:29:57 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: RAV-RM401CTP-E, 32-HC_RAV_HCL_TOSHIBA_RM1CTP_80:RAV-RM401CTP-E:259154
In: Level 1
Type - Material: Colour RGB-250 000 000, Colour- RGB 255 255 255
Pset_ManufacturerTypeInformation - Manufacturer: Toshiba
Pset_BuildingElementProxyCommon - Reference: RAV-RM401CTP-E; IsExternal: no
